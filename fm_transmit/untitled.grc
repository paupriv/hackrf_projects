options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(70e3)
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: file.wav
    repeat: 'True'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '20'
    if_gain0: '20'
    sample_rate: samp_rate*100
    sync: none
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '100'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
